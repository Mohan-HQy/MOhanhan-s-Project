# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\Software;.\Control
  group User
    ./User/: main.c
  group Software
    ./Software/: delay.h delay.c HCSR04.c HCSR04.h Timer.c Timer.h
  group Contorl
    ./Control/: Move.c Move.h track.c track.h
